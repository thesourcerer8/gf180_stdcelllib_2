*** Spice netlist generated by cell2spice.pl from cell file vanberkel1991.cell ***

.subckt vanberkel1991 VDD GND A B C
M0 NET3 B NET5 GND nmos w=1.83u l=0.5u
M1 NET2 A VDD VDD pmos w=1.32u l=0.6u
M2 NET3 B NET2 VDD pmos w=1.32u l=0.6u
M3 NET1 B VDD VDD pmos w=1.32u l=0.6u
M4 NET3 A NET1 VDD pmos w=1.32u l=0.6u
M5 C NET3 VDD VDD pmos w=1.32u l=0.6u
M6 NET3 A NET4 GND nmos w=1.83u l=0.5u
M7 NET5 A GND GND nmos w=1.83u l=0.5u
M8 NET4 B GND GND nmos w=1.83u l=0.5u
M9 NET4 C NET5 GND nmos w=1.83u l=0.5u
M10 C NET3 GND GND nmos w=1.83u l=0.5u
M11 NET1 C NET2 VDD pmos w=1.32u l=0.6u
.ends vanberkel1991
