*** Spice netlist generated by cell2spice.pl from cell file OAI41.cell ***

.subckt OAI41 VDD GND B A3 A2 A1 A Y
M0 N3 B VDD VDD pmos w=1.32u l=0.6u
M1 N2 A3 VDD VDD pmos w=1.32u l=0.6u
M2 N1 A2 N2 VDD pmos w=1.32u l=0.6u
M3 N A1 N1 VDD pmos w=1.32u l=0.6u
M4 Y A N VDD pmos w=1.32u l=0.6u
M5 N3 B GND GND nmos w=1.83u l=0.5u
M6 Y A3 N3 GND nmos w=1.83u l=0.5u
M7 Y A2 N3 GND nmos w=1.83u l=0.5u
M8 Y A1 N3 GND nmos w=1.83u l=0.5u
M9 Y A N3 GND nmos w=1.83u l=0.5u
.ends OAI41
