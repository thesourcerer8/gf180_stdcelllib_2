*** Spice netlist generated by cell2spice.pl from cell file AAAOI322.cell ***

.subckt AAAOI322 VDD GND C1 C B1 B A2 A1 A Y
M0 N4 C1 VDD VDD pmos w=1.32u l=0.6u
M1 N4 C VDD VDD pmos w=1.32u l=0.6u
M2 N2 B1 N4 VDD pmos w=1.32u l=0.6u
M3 N2 B N4 VDD pmos w=1.32u l=0.6u
M4 Y A2 N2 VDD pmos w=1.32u l=0.6u
M5 Y A1 N2 VDD pmos w=1.32u l=0.6u
M6 Y A N2 VDD pmos w=1.32u l=0.6u
M7 N5 C1 GND GND nmos w=1.83u l=0.5u
M8 N4 C N5 GND nmos w=1.83u l=0.5u
M9 N3 B1 GND GND nmos w=1.83u l=0.5u
M10 N2 B N3 GND nmos w=1.83u l=0.5u
M11 N1 A2 GND GND nmos w=1.83u l=0.5u
M12 N A1 N1 GND nmos w=1.83u l=0.5u
M13 Y A N GND nmos w=1.83u l=0.5u
.ends AAAOI322
