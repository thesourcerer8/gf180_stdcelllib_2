*** Spice netlist generated by cell2spice.pl from cell file sutherland1989.cell ***

.subckt sutherland1989 VDD GND B A C
M0 NET6 B NET5 GND nmos w=1.83u l=0.5u
M1 NET2 A VDD VDD pmos w=1.32u l=0.6u
M2 NET6 B NET2 VDD pmos w=1.32u l=0.6u
M3 NET1 A VDD VDD pmos w=1.32u l=0.6u
M4 NET1 B VDD VDD pmos w=1.32u l=0.6u
M5 NET3 C NET1 VDD pmos w=1.32u l=0.6u
M6 C NET3 VDD VDD pmos w=1.32u l=0.6u
M7 NET3 C NET4 GND nmos w=1.83u l=0.5u
M8 NET5 A GND GND nmos w=1.83u l=0.5u
M9 NET4 B GND GND nmos w=1.83u l=0.5u
M10 NET4 A GND GND nmos w=1.83u l=0.5u
M11 C NET3 GND GND nmos w=1.83u l=0.5u
.ends sutherland1989
