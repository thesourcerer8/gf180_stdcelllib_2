*** Spice netlist generated by cell2spice.pl from cell file NOR3.cell ***

.subckt NOR3 VDD GND A2 A1 A Y
M0 N1 A2 VDD VDD pmos w=1.32u l=0.6u
M1 N A1 N1 VDD pmos w=1.32u l=0.6u
M2 Y A N VDD pmos w=1.32u l=0.6u
M3 Y A2 GND GND nmos w=1.83u l=0.5u
M4 Y A1 GND GND nmos w=1.83u l=0.5u
M5 Y A GND GND nmos w=1.83u l=0.5u
.ends NOR3
