*** Spice netlist generated by cell2spice.pl from cell file OAOOAAOI21132.cell ***

.subckt OAOOAAOI21132 VDD GND E1 E D2 D1 D C B A1 A Y
M0 N6 E1 VDD VDD pmos w=1.32u l=0.6u
M1 N6 E VDD VDD pmos w=1.32u l=0.6u
M2 N5 D2 N6 VDD pmos w=1.32u l=0.6u
M3 N4 D1 N5 VDD pmos w=1.32u l=0.6u
M4 N3 D N4 VDD pmos w=1.32u l=0.6u
M5 N2 C N6 VDD pmos w=1.32u l=0.6u
M6 N1 B N2 VDD pmos w=1.32u l=0.6u
M7 N A1 N2 VDD pmos w=1.32u l=0.6u
M8 Y A N VDD pmos w=1.32u l=0.6u
M9 N7 E1 GND GND nmos w=1.83u l=0.5u
M10 N6 E N7 GND nmos w=1.83u l=0.5u
M11 N3 D2 GND GND nmos w=1.83u l=0.5u
M12 N3 D1 GND GND nmos w=1.83u l=0.5u
M13 N3 D GND GND nmos w=1.83u l=0.5u
M14 N2 C N3 GND nmos w=1.83u l=0.5u
M15 N1 B N3 GND nmos w=1.83u l=0.5u
M16 Y A1 N1 GND nmos w=1.83u l=0.5u
M17 Y A N1 GND nmos w=1.83u l=0.5u
.ends OAOOAAOI21132
